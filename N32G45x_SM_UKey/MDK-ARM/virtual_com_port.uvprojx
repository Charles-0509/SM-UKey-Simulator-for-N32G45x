# Keil uVision project virtual_com_port.uvprojx, settings and files
target N32G45x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G457QEL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.0.6
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Virtual_COM_Port +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32G45X, USE_STDPERIPH_DRIVER,USE_FULL_ASSERT=1
  c include: ..\user\inc;..\app;..\port;..\libraries\CMSIS\core;..\libraries\CMSIS\device;..\libraries\std_periph\inc;..\libraries\usbfs\inc;..\libraries\algo\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group STARTUP
    ../libraries/CMSIS/device/startup/: startup_n32g45x.s
  group CMSIS
    ../libraries/CMSIS/device/: system_n32g45x.c
  group FWLB
    ../libraries/std_periph/src/: misc.c n32g45x_dma.c n32g45x_exti.c n32g45x_flash.c n32g45x_gpio.c n32g45x_rcc.c n32g45x_usart.c n32g45x_pwr.c n32g45x_dbg.c
  group USER
    ../user/src/: main.c n32g45x_it.c hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group SM_UKEY_APP
    ../app/: secure_store.c ukey_protocol.c ukey_state.c utils_hex.c
  group SM_UKEY_PORT
    ../port/: crypto_n32g45x.c platform_n32g45x.c software_sm2.c software_sm4.c ukey_usb_bridge.c ukey_uart_bridge.c ukey_buttons.c
  group N32_ALGO_LIB
    ../libraries/algo/lib/: n32g45x_algo_common.lib n32g45x_hash.lib n32g45x_rng.lib
  group DOC
    ../: readme_official_usb.txt
  group n32g45x_usbfs_driver
    ../libraries/usbfs/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
